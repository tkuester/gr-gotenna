<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gotenna_gui</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud_rate</value></param>
<param><key>value</key><value>2400</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>153.1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ch_freqs</value></param>
<param><key>value</key><value>[151.82e6, 151.88e6, 151.94e6, 154.57e6, 154.6e6]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>if_rate</value></param>
<param><key>value</key><value>samp_rate/16/8</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>value</key><value>10</value></param>
<param><key>gui_hint</key><value>1,1,1,2</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>79</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>4e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>if_rate/baud_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_word_bits</value></param>
<param><key>comment</key><value>Including 4 bits of preamble to help suppress
false positives on sync</value></param>
<param><key>value</key><value>[1,0]*8 + map(int, bin(0x2dd4)[2:].zfill(16))</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>1</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0_0</value></param>
<param><key>gain</key><value>1</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0_0_0</value></param>
<param><key>gain</key><value>1</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0_0_1</value></param>
<param><key>gain</key><value>1</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0_0_1_0</value></param>
<param><key>gain</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0_0</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0_0_0</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0_0_1</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0_0_1_0</value></param>
</block>
<block>
<key>gotenna_gotenna_sink</key>
<param><key>id</key><value>gotenna_gotenna_sink_0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>4800</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>if_rate</value></param>
<param><key>width</key><value>2400</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>cutoff_freq</key><value>4800</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>if_rate</value></param>
<param><key>width</key><value>2400</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0_0</value></param>
<param><key>cutoff_freq</key><value>4800</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>if_rate</value></param>
<param><key>width</key><value>2400</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0_1</value></param>
<param><key>cutoff_freq</key><value>4800</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>if_rate</value></param>
<param><key>width</key><value>2400</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0_1_0</value></param>
<param><key>cutoff_freq</key><value>4800</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>if_rate</value></param>
<param><key>width</key><value>2400</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>nwr_symbol_sync_xx</key>
<param><key>id</key><value>nwr_symbol_sync_xx_0</value></param>
<param><key>damping</key><value>1.5</value></param>
<param><key>nfilters</key><value>128</value></param>
<param><key>type</key><value>ff</value></param>
<param><key>resamp_type</key><value>nwr.interpolating_resampler.IR_MMSE_8TAP</value></param>
<param><key>loop_bw</key><value>2*math.pi*0.045</value></param>
<param><key>max_dev</key><value>1.25</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>pfb_mf_taps</key><value>[]</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>constellation</key><value>digital.constellation_bpsk().base()</value></param>
<param><key>ted_type</key><value>nwr.timing_error_detector.TED_GARDNER</value></param>
</block>
<block>
<key>nwr_symbol_sync_xx</key>
<param><key>id</key><value>nwr_symbol_sync_xx_0_0</value></param>
<param><key>damping</key><value>1.5</value></param>
<param><key>nfilters</key><value>128</value></param>
<param><key>type</key><value>ff</value></param>
<param><key>resamp_type</key><value>nwr.interpolating_resampler.IR_MMSE_8TAP</value></param>
<param><key>loop_bw</key><value>2*math.pi*0.045</value></param>
<param><key>max_dev</key><value>1.25</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>pfb_mf_taps</key><value>[]</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>constellation</key><value>digital.constellation_bpsk().base()</value></param>
<param><key>ted_type</key><value>nwr.timing_error_detector.TED_GARDNER</value></param>
</block>
<block>
<key>nwr_symbol_sync_xx</key>
<param><key>id</key><value>nwr_symbol_sync_xx_0_0_0</value></param>
<param><key>damping</key><value>1.5</value></param>
<param><key>nfilters</key><value>128</value></param>
<param><key>type</key><value>ff</value></param>
<param><key>resamp_type</key><value>nwr.interpolating_resampler.IR_MMSE_8TAP</value></param>
<param><key>loop_bw</key><value>2*math.pi*0.045</value></param>
<param><key>max_dev</key><value>1.25</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>pfb_mf_taps</key><value>[]</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>constellation</key><value>digital.constellation_bpsk().base()</value></param>
<param><key>ted_type</key><value>nwr.timing_error_detector.TED_GARDNER</value></param>
</block>
<block>
<key>nwr_symbol_sync_xx</key>
<param><key>id</key><value>nwr_symbol_sync_xx_0_0_1</value></param>
<param><key>damping</key><value>1.5</value></param>
<param><key>nfilters</key><value>128</value></param>
<param><key>type</key><value>ff</value></param>
<param><key>resamp_type</key><value>nwr.interpolating_resampler.IR_MMSE_8TAP</value></param>
<param><key>loop_bw</key><value>2*math.pi*0.045</value></param>
<param><key>max_dev</key><value>1.25</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>pfb_mf_taps</key><value>[]</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>constellation</key><value>digital.constellation_bpsk().base()</value></param>
<param><key>ted_type</key><value>nwr.timing_error_detector.TED_GARDNER</value></param>
</block>
<block>
<key>nwr_symbol_sync_xx</key>
<param><key>id</key><value>nwr_symbol_sync_xx_0_0_1_0</value></param>
<param><key>damping</key><value>1.5</value></param>
<param><key>nfilters</key><value>128</value></param>
<param><key>type</key><value>ff</value></param>
<param><key>resamp_type</key><value>nwr.interpolating_resampler.IR_MMSE_8TAP</value></param>
<param><key>loop_bw</key><value>2*math.pi*0.045</value></param>
<param><key>max_dev</key><value>1.25</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>pfb_mf_taps</key><value>[]</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>constellation</key><value>digital.constellation_bpsk().base()</value></param>
<param><key>ted_type</key><value>nwr.timing_error_detector.TED_GARDNER</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>6</value></param>
<param><key>bw0</key><value>samp_rate</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>0</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>pfb_decimator_ccf</key>
<param><key>id</key><value>pfb_decimator_ccf_1</value></param>
<param><key>comment</key><value>[151.725, 151.850, 151.975] @ 250 ksps</value></param>
<param><key>decim</key><value>16</value></param>
<param><key>channel</key><value>11</value></param>
<param><key>atten</key><value>100</value></param>
</block>
<block>
<key>pfb_decimator_ccf</key>
<param><key>id</key><value>pfb_decimator_ccf_1_0</value></param>
<param><key>comment</key><value>[154.537, 154.6, 154.662] @ 125 ksps</value></param>
<param><key>decim</key><value>32</value></param>
<param><key>channel</key><value>12</value></param>
<param><key>atten</key><value>100</value></param>
</block>
<block>
<key>pfb_decimator_ccf</key>
<param><key>id</key><value>pfb_decimator_ccf_1_1</value></param>
<param><key>comment</key><value>ch4: 154.6M @ 31.25e3</value></param>
<param><key>decim</key><value>4</value></param>
<param><key>channel</key><value>0</value></param>
<param><key>atten</key><value>100</value></param>
</block>
<block>
<key>pfb_decimator_ccf</key>
<param><key>id</key><value>pfb_decimator_ccf_1_1_0</value></param>
<param><key>comment</key><value>ch3: 154.56875 @ 31.25e3</value></param>
<param><key>decim</key><value>4</value></param>
<param><key>channel</key><value>3</value></param>
<param><key>atten</key><value>100</value></param>
</block>
<block>
<key>pfb_decimator_ccf</key>
<param><key>id</key><value>pfb_decimator_ccf_1_2</value></param>
<param><key>comment</key><value>ch0: 151.81875</value></param>
<param><key>decim</key><value>8</value></param>
<param><key>channel</key><value>7</value></param>
<param><key>atten</key><value>100</value></param>
</block>
<block>
<key>pfb_decimator_ccf</key>
<param><key>id</key><value>pfb_decimator_ccf_1_2_0</value></param>
<param><key>comment</key><value>ch1: 151.88125</value></param>
<param><key>decim</key><value>8</value></param>
<param><key>channel</key><value>1</value></param>
<param><key>atten</key><value>100</value></param>
</block>
<block>
<key>pfb_decimator_ccf</key>
<param><key>id</key><value>pfb_decimator_ccf_1_2_0_0</value></param>
<param><key>comment</key><value>ch2: 151.94375</value></param>
<param><key>decim</key><value>8</value></param>
<param><key>channel</key><value>3</value></param>
<param><key>atten</key><value>100</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>3,1,1,1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>1.0/30</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>bw</key><value>31.25e3</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>label2</key><value></value></param>
<param><key>label3</key><value></value></param>
<param><key>label4</key><value></value></param>
<param><key>label5</key><value></value></param>
<param><key>nconnections</key><value>5</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>tr_tag</key><value>"rx_sob"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>1.0/30</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1</value></param>
<param><key>bw</key><value>31.25e3</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>3,2,1,1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>1.0/30</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>2,1,1,2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>10240</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_chan</key><value>1</value></param>
<param><key>tr_level</key><value>0.0002</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>reveng_packet_deframer</key>
<param><key>id</key><value>reveng_packet_deframer_0_2_0_0_0_0</value></param>
<param><key>pkt_len_adj</key><value>0</value></param>
<param><key>encoding</key><value>none</value></param>
<param><key>big_endian</key><value>True</value></param>
<param><key>pkt_len_offset</key><value>0</value></param>
<param><key>msb</key><value>True</value></param>
<param><key>max_len</key><value>0</value></param>
<param><key>fixed_len</key><value>True</value></param>
<param><key>name</key><value>ch4</value></param>
<param><key>pack_bytes</key><value>True</value></param>
<param><key>pkt_len</key><value>18*8</value></param>
<param><key>sync</key><value>sync_word_bits</value></param>
</block>
<block>
<key>reveng_packet_deframer</key>
<param><key>id</key><value>reveng_packet_deframer_0_2_0_0_0_0_0</value></param>
<param><key>pkt_len_adj</key><value>10</value></param>
<param><key>encoding</key><value>none</value></param>
<param><key>big_endian</key><value>True</value></param>
<param><key>pkt_len_offset</key><value>19</value></param>
<param><key>msb</key><value>True</value></param>
<param><key>max_len</key><value>70</value></param>
<param><key>fixed_len</key><value>False</value></param>
<param><key>name</key><value>ch3</value></param>
<param><key>pack_bytes</key><value>True</value></param>
<param><key>pkt_len</key><value>32</value></param>
<param><key>sync</key><value>sync_word_bits</value></param>
</block>
<block>
<key>reveng_packet_deframer</key>
<param><key>id</key><value>reveng_packet_deframer_0_2_0_0_0_0_0_0</value></param>
<param><key>pkt_len_adj</key><value>10</value></param>
<param><key>encoding</key><value>none</value></param>
<param><key>big_endian</key><value>True</value></param>
<param><key>pkt_len_offset</key><value>19</value></param>
<param><key>msb</key><value>True</value></param>
<param><key>max_len</key><value>70</value></param>
<param><key>fixed_len</key><value>False</value></param>
<param><key>name</key><value>ch2</value></param>
<param><key>pack_bytes</key><value>True</value></param>
<param><key>pkt_len</key><value>32</value></param>
<param><key>sync</key><value>sync_word_bits</value></param>
</block>
<block>
<key>reveng_packet_deframer</key>
<param><key>id</key><value>reveng_packet_deframer_0_2_0_0_0_0_0_1</value></param>
<param><key>pkt_len_adj</key><value>10</value></param>
<param><key>encoding</key><value>none</value></param>
<param><key>big_endian</key><value>True</value></param>
<param><key>pkt_len_offset</key><value>19</value></param>
<param><key>msb</key><value>True</value></param>
<param><key>max_len</key><value>70</value></param>
<param><key>fixed_len</key><value>False</value></param>
<param><key>name</key><value>ch1</value></param>
<param><key>pack_bytes</key><value>True</value></param>
<param><key>pkt_len</key><value>32</value></param>
<param><key>sync</key><value>sync_word_bits</value></param>
</block>
<block>
<key>reveng_packet_deframer</key>
<param><key>id</key><value>reveng_packet_deframer_0_2_0_0_0_0_0_1_0</value></param>
<param><key>pkt_len_adj</key><value>10</value></param>
<param><key>encoding</key><value>none</value></param>
<param><key>big_endian</key><value>True</value></param>
<param><key>pkt_len_offset</key><value>19</value></param>
<param><key>msb</key><value>True</value></param>
<param><key>max_len</key><value>70</value></param>
<param><key>fixed_len</key><value>False</value></param>
<param><key>name</key><value>ch0</value></param>
<param><key>pack_bytes</key><value>True</value></param>
<param><key>pkt_len</key><value>32</value></param>
<param><key>sync</key><value>sync_word_bits</value></param>
</block>
<block>
<key>reveng_packet_formatter</key>
<param><key>id</key><value>reveng_packet_formatter_0</value></param>
<param><key>append</key><value>True</value></param>
<param><key>comment</key><value>Since this packet is always the same len,
splitting it up into fields. Will not play well
w/ two blocks sharing stdout</value></param>
<param><key>file_name</key><value>/tmp/gotenna.log</value></param>
<param><key>flush</key><value>True</value></param>
<param><key>format_str</key><value>%(ts),%(name),%(hex)</value></param>
<param><key>log_to</key><value>"file"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>short_id</key><value>g</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>alpha</key><value>0.01</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>ch0</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>ch1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0</value></param>
<param><key>stream_id</key><value>ch2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_0</value></param>
<param><key>stream_id</key><value>ch3</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_0_0</value></param>
<param><key>stream_id</key><value>ch4</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>ch0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>ch1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>ch3</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>ch2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>ch4</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_1_0</value></param>
<param><key>stream_id</key><value>ch4</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_1_0_0</value></param>
<param><key>stream_id</key><value>ch3</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_1_0_0_0</value></param>
<param><key>stream_id</key><value>ch2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_1_0_0_1</value></param>
<param><key>stream_id</key><value>ch1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_1_0_0_1_0</value></param>
<param><key>stream_id</key><value>ch0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1</value></param>
<param><key>stream_id</key><value>ch4</value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0_0</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0_0_0</source_block_id><sink_block_id>low_pass_filter_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0_0_1</source_block_id><sink_block_id>low_pass_filter_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0_0_1_0</source_block_id><sink_block_id>low_pass_filter_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>reveng_packet_deframer_0_2_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0_0</source_block_id><sink_block_id>reveng_packet_deframer_0_2_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0_0_0</source_block_id><sink_block_id>reveng_packet_deframer_0_2_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0_0_1</source_block_id><sink_block_id>reveng_packet_deframer_0_2_0_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0_0_1_0</source_block_id><sink_block_id>reveng_packet_deframer_0_2_0_0_0_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>nwr_symbol_sync_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>nwr_symbol_sync_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0_0</source_block_id><sink_block_id>nwr_symbol_sync_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0_1</source_block_id><sink_block_id>nwr_symbol_sync_xx_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0_1_0</source_block_id><sink_block_id>nwr_symbol_sync_xx_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_symbol_sync_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_symbol_sync_xx_0_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_symbol_sync_xx_0_0_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_symbol_sync_xx_0_0_1</source_block_id><sink_block_id>digital_binary_slicer_fb_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nwr_symbol_sync_xx_0_0_1_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>pfb_decimator_ccf_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>pfb_decimator_ccf_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_decimator_ccf_1</source_block_id><sink_block_id>pfb_decimator_ccf_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_decimator_ccf_1</source_block_id><sink_block_id>pfb_decimator_ccf_1_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_decimator_ccf_1</source_block_id><sink_block_id>pfb_decimator_ccf_1_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_decimator_ccf_1_0</source_block_id><sink_block_id>pfb_decimator_ccf_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_decimator_ccf_1_0</source_block_id><sink_block_id>pfb_decimator_ccf_1_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_decimator_ccf_1_1</source_block_id><sink_block_id>virtual_sink_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_decimator_ccf_1_1_0</source_block_id><sink_block_id>virtual_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_decimator_ccf_1_2</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_decimator_ccf_1_2_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_decimator_ccf_1_2_0_0</source_block_id><sink_block_id>virtual_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>reveng_packet_deframer_0_2_0_0_0_0</source_block_id><sink_block_id>gotenna_gotenna_sink_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>reveng_packet_deframer_0_2_0_0_0_0</source_block_id><sink_block_id>reveng_packet_formatter_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>reveng_packet_deframer_0_2_0_0_0_0_0</source_block_id><sink_block_id>gotenna_gotenna_sink_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>reveng_packet_deframer_0_2_0_0_0_0_0</source_block_id><sink_block_id>reveng_packet_formatter_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>reveng_packet_deframer_0_2_0_0_0_0_0_0</source_block_id><sink_block_id>gotenna_gotenna_sink_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>reveng_packet_deframer_0_2_0_0_0_0_0_0</source_block_id><sink_block_id>reveng_packet_formatter_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>reveng_packet_deframer_0_2_0_0_0_0_0_1</source_block_id><sink_block_id>gotenna_gotenna_sink_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>reveng_packet_deframer_0_2_0_0_0_0_0_1</source_block_id><sink_block_id>reveng_packet_formatter_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>reveng_packet_deframer_0_2_0_0_0_0_0_1_0</source_block_id><sink_block_id>gotenna_gotenna_sink_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>reveng_packet_deframer_0_2_0_0_0_0_0_1_0</source_block_id><sink_block_id>reveng_packet_formatter_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_1_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_1_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_1_0_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_1_0_0_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_1_0_0_1</source_block_id><sink_block_id>analog_quadrature_demod_cf_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_1_0_0_1_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
